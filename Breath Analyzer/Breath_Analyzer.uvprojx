# Keil uVision project Breath_Analyzer.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Breath_Analyzer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: .\Inc;.\Drivers\PY32F0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Src
    ./Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c fonts.c ssd1306.c
  group HAL_Drivers/Inc
    ./Drivers/PY32F0xx_HAL_Driver/Inc/: py32f0xx_hal.h py32f0xx_hal_adc.h py32f0xx_hal_adc_ex.h py32f0xx_hal_comp.h py32f0xx_hal_cortex.h py32f0xx_hal_crc.h py32f0xx_hal_def.h py32f0xx_hal_dma.h py32f0xx_hal_dma_ex.h py32f0xx_hal_exti.h py32f0xx_hal_flash.h py32f0xx_hal_flash_ex.h py32f0xx_hal_gpio.h py32f0xx_hal_gpio_ex.h py32f0xx_hal_i2c.h py32f0xx_hal_irda.h py32f0xx_hal_iwdg.h py32f0xx_hal_led.h py32f0xx_hal_lptim.h py32f0xx_hal_pwr.h py32f0xx_hal_rcc.h py32f0xx_hal_rcc_ex.h py32f0xx_hal_rtc.h py32f0xx_hal_rtc_ex.h py32f0xx_hal_spi.h py32f0xx_hal_tim.h py32f0xx_hal_tim_ex.h py32f0xx_hal_uart.h py32f0xx_hal_usart.h py32f0xx_hal_wwdg.h py32f0xx_ll_adc.h py32f0xx_ll_bus.h py32f0xx_ll_comp.h py32f0xx_ll_cortex.h py32f0xx_ll_crc.h py32f0xx_ll_dma.h py32f0xx_ll_exti.h py32f0xx_ll_gpio.h py32f0xx_ll_i2c.h py32f0xx_ll_iwdg.h py32f0xx_ll_led.h py32f0xx_ll_lptim.h py32f0xx_ll_pwr.h py32f0xx_ll_rcc.h py32f0xx_ll_rtc.h py32f0xx_ll_spi.h py32f0xx_ll_system.h py32f0xx_ll_tim.h py32f0xx_ll_usart.h py32f0xx_ll_utils.h py32f0xx_ll_wwdg.h
  group HAL_Drivers/Src
    ./Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_utils.c
  group Inc
    ./Inc/: main.h py32f0xx_hal_conf.h py32f0xx_it.h fonts.h ssd1306.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
